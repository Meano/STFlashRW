# Keil uVision project FlashRW.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446ZEJx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: QRCode +hex
  AfterMake: D:\Software\Develop\MDK5\ARM\ARMCC\bin\fromelf.exe --bin  -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F446xx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c include: ..\..\Library\CMSIS\Include;..\..\Library\STM32F4xx\Include;..\..\Library\STM32USB\Device\Include;..\..\Library\STM32USB\OTG\Include;..\..\Library\STM32USBMSC\Include;..\..\BSP\Include;..\..\User\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT8: RAM 0xc0000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../../User/Source/: FlashRWMain.c W25Q.c
  group BSP
    ../../BSP/Source/: Clock.c Delay.c SCCB.c DCMI.c GPIO.c SDRAM.c Timer.c USART.c usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c Config_GC0308.c Config_OV7725.c VirtualFatFS.c
  group Startup
    ../../Library/Startup/: startup_stm32f446xx.s startup_stm32f40_41xxx.s startup_stm32f40xx.s startup_stm32f401xx.s startup_stm32f410xx.s startup_stm32f411xe.s startup_stm32f412xg.s startup_stm32f413_423xx.s startup_stm32f427_437xx.s startup_stm32f427x.s startup_stm32f429_439xx.s startup_stm32f469_479xx.s
  group STM32F4xx
    ../../Library/STM32F4xx/Source/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32USB
    ../../Library/STM32USB/OTG/Source/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32USBMSC
    ../../Library/STM32USB/Device/Source/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Library/STM32USBMSC/Source/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
